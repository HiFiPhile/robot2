# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; DEBUG=1
  ICCSTM8.CCIncludePath2: ..\Inc; ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  OBJCOPY.OOCOutputFile: project.srec
configuration Debug_Simulator (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S207CB STM8S207CB
  ICCSTM8.CCDefines: DEBUG=1; STM8S207
  OBJCOPY.OOCOutputFile: project.bin
  group (top)
    ./: Readme.txt
  group embOS
    ../Setup/: OS_Error.c Rtosinit_STM8.c Start_STM8_Sim.mac
    ../Lib/: osSTM8mm_DP.a osSTM8mm_R.a
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
  group User
    ../: main.c route.c stm8s_it.c
